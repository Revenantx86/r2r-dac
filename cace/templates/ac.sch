** sch_path: cace/templates/ac.sch
**.subckt ac
I0 VDD Ib CACE{ib}
C1 Vout GND CACE{cl} m=1
V0 VSS GND 0
V2 VDD GND CACE{vdd}
E1 Vp net2 net1 GND 0.5
E2 Vn net2 net1 GND -0.5
Vdm net1 GND ac 1
Vcm net2 GND CACE{vcm}
X1 Ib Vn Vp Vout VDD VSS ota_5t
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control
    * run ac simulation
    ac dec 20 1k 100e6

    * measure parameters
    let vout_mag = abs(v(Vout))
    let vout_phase_margin = phase(v(Vout)) * 180/pi + 180
    meas ac A0 find vout_mag at=1k
    meas ac UGF when vout_mag=1 fall=1
    meas ac PM find vout_phase_margin when vout_mag=1

    echo $&A0 $&ugf $&PM > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  /home/unixpoly/analog/projects/sky130/ota_5t/xschem/ota_5t.sym # of pins=6
** sym_path: xschem/ota_5t.sym
** sch_path: xschem/ota_5t.sch
.subckt ota_5t Ib Vn Vp Vout VDD VSS
*.iopin VDD
*.iopin VSS
*.opin Vout
*.ipin Vp
*.ipin Vn
*.ipin Ib
XM3 net2 Vp net1 VSS sky130_fd_pr__nfet_01v8 L=0.5 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29' as='int((1
+ + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)' nrd='0.29
+ / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM1 net2 net2 VDD VDD sky130_fd_pr__pfet_01v8 L=1 W=4.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2)
+ * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 /
+ W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 Vout net2 VDD VDD sky130_fd_pr__pfet_01v8 L=1 W=4.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2)
+ * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 /
+ W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 Vout Vn net1 VSS sky130_fd_pr__nfet_01v8 L=0.5 W=3 nf=1 ad='int((1 + 1)/2) * 3 / 1 * 0.29' as='int((1
+ + 2)/2) * 3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3 / 1 + 0.29)' nrd='0.29
+ / 3 ' nrs='0.29 / 3 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5 net1 Ib VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6 Ib Ib VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND
.end
